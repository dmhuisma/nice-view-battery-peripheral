## boards/shields/nice_view_battery_peripheral/Kconfig.shield
```kconfig
config SHIELD_NICE_VIEW_BATTERY_PERIPHERAL
    def_bool $(shields_list_contains,nice_view_battery_peripheral)
```
